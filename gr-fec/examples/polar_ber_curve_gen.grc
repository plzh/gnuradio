<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>polar_ber_curve_gen</value></param>
<param><key>author</key><value>Johannes Demel</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>polar code BER curve generator</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>block_size</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>dec_cc</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>k</value></param>
<param><key>dim1</key><value>len(esno)</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>frame_size</value></param>
<param><key>ndim</key><value>2</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>enc_cc</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>k</value></param>
<param><key>dim1</key><value>len(esno)</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>framebits</key><value>frame_size</value></param>
<param><key>ndim</key><value>2</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>esno</value></param>
<param><key>value</key><value>numpy.arange(-1, 4, 0.5)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_size</value></param>
<param><key>value</key><value>block_size / 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>list_size</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_info_bits</value></param>
<param><key>value</key><value>block_size / 2</value></param>
</block>
<block>
<key>variable_polar_code_configurator</key>
<param><key>id</key><value>polar_config</value></param>
<param><key>num_info_bits</key><value>n_info_bits</value></param>
<param><key>block_size</key><value>block_size</value></param>
<param><key>channel</key><value>polar.CHANNEL_TYPE_BEC</value></param>
<param><key>design_snr</key><value>0.0</value></param>
<param><key>mu</key><value>32</value></param>
</block>
<block>
<key>variable_polar_decoder_sc_def</key>
<param><key>id</key><value>polar_decoder</value></param>
<param><key>num_info_bits</key><value>n_info_bits</value></param>
<param><key>block_size</key><value>block_size</value></param>
<param><key>dim1</key><value>len(esno)</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>frozen_bit_positions</key><value>polar_config['positions']</value></param>
<param><key>frozen_bit_values</key><value>polar_config['values']</value></param>
<param><key>ndim</key><value>2</value></param>
</block>
<block>
<key>variable_polar_encoder_def</key>
<param><key>id</key><value>polar_encoder</value></param>
<param><key>num_info_bits</key><value>n_info_bits</value></param>
<param><key>block_size</key><value>block_size</value></param>
<param><key>dim1</key><value>len(esno)</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>frozen_bit_positions</key><value>polar_config['positions']</value></param>
<param><key>frozen_bit_values</key><value>polar_config['values']</value></param>
<param><key>is_packed</key><value>False</value></param>
<param><key>ndim</key><value>2</value></param>
</block>
<block>
<key>variable_polar_encoder_def</key>
<param><key>id</key><value>polar_encoder_scld</value></param>
<param><key>num_info_bits</key><value>n_info_bits</value></param>
<param><key>block_size</key><value>block_size</value></param>
<param><key>dim1</key><value>len(esno)</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>frozen_bit_positions</key><value>polar_config['positions']</value></param>
<param><key>frozen_bit_values</key><value>polar_config['values']</value></param>
<param><key>is_packed</key><value>False</value></param>
<param><key>ndim</key><value>2</value></param>
</block>
<block>
<key>variable_polar_decoder_sc_list_def</key>
<param><key>id</key><value>polar_scld</value></param>
<param><key>num_info_bits</key><value>n_info_bits</value></param>
<param><key>block_size</key><value>block_size</value></param>
<param><key>dim1</key><value>len(esno)</value></param>
<param><key>dim2</key><value>1</value></param>
<param><key>frozen_bit_positions</key><value>polar_config['positions']</value></param>
<param><key>frozen_bit_values</key><value>polar_config['values']</value></param>
<param><key>max_list_size</key><value>list_size</value></param>
<param><key>ndim</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[79, 109]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>350e3</value></param>
</block>
<block>
<key>fec_bercurve_generator</key>
<param><key>id</key><value>polar_curve_gen_sc</value></param>
<param><key>decoder_list</key><value>polar_decoder</value></param>
<param><key>encoder_list</key><value>polar_encoder</value></param>
<param><key>esno</key><value>esno</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>samp_rate</key><value>3200000</value></param>
<param><key>threadtype</key><value>"none"</value></param>
<bus_source>1</bus_source>
</block>
<block>
<key>fec_bercurve_generator</key>
<param><key>id</key><value>polar_curve_gen_scld</value></param>
<param><key>decoder_list</key><value>polar_scld</value></param>
<param><key>encoder_list</key><value>polar_encoder_scld</value></param>
<param><key>esno</key><value>esno</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>samp_rate</key><value>3200000</value></param>
<param><key>threadtype</key><value>"none"</value></param>
<bus_source>1</bus_source>
</block>
<block>
<key>fec_bercurve_generator</key>
<param><key>id</key><value>polar_curve_gen_scld_0</value></param>
<param><key>decoder_list</key><value>dec_cc</value></param>
<param><key>encoder_list</key><value>enc_cc</value></param>
<param><key>esno</key><value>esno</value></param>
<param><key>puncpat</key><value>'11'</value></param>
<param><key>samp_rate</key><value>3200000</value></param>
<bus_source>1</bus_source>
</block>
<block>
<key>qtgui_bercurve_sink</key>
<param><key>id</key><value>qtgui_bercurve_sink_0</value></param>
<param><key>berlimit</key><value>-7.0</value></param>
<param><key>curvenames</key><value>['POLAR decoder', 'POLAR decoder list', 'CC']</value></param>
<param><key>label1</key><value>POLAR decoder</value></param>
<param><key>label2</key><value>POLAR list decoder</value></param>
<param><key>label3</key><value>CC convolutional</value></param>
<param><key>berminerrors</key><value>100</value></param>
<param><key>num_curves</key><value>3</value></param>
<param><key>esno</key><value>esno</value></param>
<bus_sink>1</bus_sink>
</block>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>20</source_key><sink_key>60</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>10</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>11</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>12</source_key><sink_key>12</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>13</source_key><sink_key>13</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>14</source_key><sink_key>14</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>15</source_key><sink_key>15</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>16</source_key><sink_key>16</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>17</source_key><sink_key>17</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>18</source_key><sink_key>18</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>19</source_key><sink_key>19</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>7</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>8</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>polar_curve_gen_sc</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>9</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>20</source_key><sink_key>61</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>0</source_key><sink_key>20</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>1</source_key><sink_key>21</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>10</source_key><sink_key>30</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>11</source_key><sink_key>31</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>12</source_key><sink_key>32</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>13</source_key><sink_key>33</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>14</source_key><sink_key>34</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>15</source_key><sink_key>35</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>16</source_key><sink_key>36</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>17</source_key><sink_key>37</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>18</source_key><sink_key>38</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>19</source_key><sink_key>39</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>2</source_key><sink_key>22</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>3</source_key><sink_key>23</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>4</source_key><sink_key>24</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>5</source_key><sink_key>25</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>6</source_key><sink_key>26</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>7</source_key><sink_key>27</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>8</source_key><sink_key>28</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>9</source_key><sink_key>29</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>20</source_key><sink_key>62</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>0</source_key><sink_key>40</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>1</source_key><sink_key>41</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>10</source_key><sink_key>50</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>11</source_key><sink_key>51</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>12</source_key><sink_key>52</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>13</source_key><sink_key>53</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>14</source_key><sink_key>54</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>15</source_key><sink_key>55</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>16</source_key><sink_key>56</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>17</source_key><sink_key>57</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>18</source_key><sink_key>58</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>19</source_key><sink_key>59</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>2</source_key><sink_key>42</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>3</source_key><sink_key>43</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>4</source_key><sink_key>44</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>5</source_key><sink_key>45</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>6</source_key><sink_key>46</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>7</source_key><sink_key>47</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>8</source_key><sink_key>48</sink_key></connection>
<connection><source_block_id>polar_curve_gen_scld_0</source_block_id><sink_block_id>qtgui_bercurve_sink_0</sink_block_id><source_key>9</source_key><sink_key>49</sink_key></connection>
</flow_graph>
