<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>vv018_miso</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>429e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>(8000000.0) * 8 / 7</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>stop</key><value>89</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>vvtx1.cfile</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>vvtx2.cfile</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/run/shm/vv018-miso.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0</value></param>
<param><key>const</key><value>0.2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0_0</value></param>
<param><key>const</key><value>0.2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_len</key><value>32768/16</value></param>
<param><key>input_size</key><value>32768</value></param>
<param><key>tagname</key><value></value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0_0</value></param>
<param><key>cp_len</key><value>32768/16</value></param>
<param><key>input_size</key><value>32768</value></param>
<param><key>tagname</key><value></value></param>
</block>
<block>
<key>dtv_dvb_bbheader_bb</key>
<param><key>id</key><value>dtv_dvb_bbheader_bb_0</value></param>
<param><key>mode</key><value>INPUTMODE_HIEFF</value></param>
<param><key>rate1</key><value>C5_6</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>inband</key><value>INBAND_OFF</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_bbscrambler_bb</key>
<param><key>id</key><value>dtv_dvb_bbscrambler_bb_0</value></param>
<param><key>rate1</key><value>C5_6</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_bch_bb</key>
<param><key>id</key><value>dtv_dvb_bch_bb_0</value></param>
<param><key>rate1</key><value>C5_6</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_ldpc_bb</key>
<param><key>id</key><value>dtv_dvb_ldpc_bb_0</value></param>
<param><key>rate1</key><value>C5_6</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvbt2_cellinterleaver_cc</key>
<param><key>id</key><value>dtv_dvbt2_cellinterleaver_cc_0</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>fecblocks</key><value>61</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>tiblocks</key><value>1</value></param>
</block>
<block>
<key>dtv_dvbt2_framemapper_cc</key>
<param><key>id</key><value>dtv_dvbt2_framemapper_cc_0</value></param>
<param><key>rate</key><value>C5_6</value></param>
<param><key>rotation</key><value>ROTATION_ON</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fecblocks</key><value>61</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>fftsize1</key><value>FFTSIZE_32K</value></param>
<param><key>guardinterval</key><value>GI_1_16</value></param>
<param><key>l1constellation</key><value>L1_MOD_64QAM</value></param>
<param><key>numdatasyms</key><value>19</value></param>
<param><key>paprmode1</key><value>PAPR_OFF</value></param>
<param><key>pilotpattern</key><value>PILOT_PP2</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_MISO</value></param>
<param><key>version</key><value>VERSION_111</value></param>
<param><key>t2frames</key><value>2</value></param>
<param><key>tiblocks</key><value>1</value></param>
</block>
<block>
<key>dtv_dvbt2_freqinterleaver_cc</key>
<param><key>id</key><value>dtv_dvbt2_freqinterleaver_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_32K</value></param>
<param><key>guardinterval</key><value>GI_1_16</value></param>
<param><key>numdatasyms</key><value>19</value></param>
<param><key>paprmode1</key><value>PAPR_OFF</value></param>
<param><key>pilotpattern</key><value>PILOT_PP2</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_MISO</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<block>
<key>dtv_dvbt2_interleaver_bb</key>
<param><key>id</key><value>dtv_dvbt2_interleaver_bb_0</value></param>
<param><key>rate</key><value>C5_6</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
</block>
<block>
<key>dtv_dvbt2_miso_cc</key>
<param><key>id</key><value>dtv_dvbt2_miso_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_32K</value></param>
<param><key>guardinterval</key><value>GI_1_16</value></param>
<param><key>numdatasyms</key><value>19</value></param>
<param><key>paprmode1</key><value>PAPR_OFF</value></param>
<param><key>pilotpattern</key><value>PILOT_PP2</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<block>
<key>dtv_dvbt2_modulator_bc</key>
<param><key>id</key><value>dtv_dvbt2_modulator_bc_0</value></param>
<param><key>rotation</key><value>ROTATION_ON</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
</block>
<block>
<key>dtv_dvbt2_p1insertion_cc</key>
<param><key>id</key><value>dtv_dvbt2_p1insertion_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize1</key><value>FFTSIZE_32K</value></param>
<param><key>guardinterval</key><value>GI_1_16</value></param>
<param><key>numdatasyms</key><value>19</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_MISO</value></param>
<param><key>showlevels</key><value>SHOWLEVELS_OFF</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<block>
<key>dtv_dvbt2_p1insertion_cc</key>
<param><key>id</key><value>dtv_dvbt2_p1insertion_cc_0_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize1</key><value>FFTSIZE_32K</value></param>
<param><key>guardinterval</key><value>GI_1_16</value></param>
<param><key>numdatasyms</key><value>19</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_MISO</value></param>
<param><key>showlevels</key><value>SHOWLEVELS_OFF</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<block>
<key>dtv_dvbt2_pilotgenerator_cc</key>
<param><key>id</key><value>dtv_dvbt2_pilotgenerator_cc_0</value></param>
<param><key>bandwidth</key><value>BANDWIDTH_8_0_MHZ</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_32K</value></param>
<param><key>guardinterval</key><value>GI_1_16</value></param>
<param><key>misogroup</key><value>MISO_TX2</value></param>
<param><key>numdatasyms</key><value>19</value></param>
<param><key>paprmode1</key><value>PAPR_OFF</value></param>
<param><key>pilotpattern</key><value>PILOT_PP2</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_MISO</value></param>
<param><key>equalization</key><value>EQUALIZATION_OFF</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<block>
<key>dtv_dvbt2_pilotgenerator_cc</key>
<param><key>id</key><value>dtv_dvbt2_pilotgenerator_cc_1</value></param>
<param><key>bandwidth</key><value>BANDWIDTH_8_0_MHZ</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_32K</value></param>
<param><key>guardinterval</key><value>GI_1_16</value></param>
<param><key>misogroup</key><value>MISO_TX1</value></param>
<param><key>numdatasyms</key><value>19</value></param>
<param><key>paprmode1</key><value>PAPR_OFF</value></param>
<param><key>pilotpattern</key><value>PILOT_PP2</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_MISO</value></param>
<param><key>equalization</key><value>EQUALIZATION_OFF</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>uhd.tune_request(center_freq, 4000000)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>ant1</key><value></value></param>
<param><key>center_freq1</key><value>uhd.tune_request(center_freq, 4000000)</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"send_frame_size=65536,num_send_frames=128,master_clock_rate=" + str(samp_rate*2)</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>dtv_dvb_bbheader_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>dtv_dvbt2_p1insertion_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0_0</source_block_id><sink_block_id>dtv_dvbt2_p1insertion_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bbheader_bb_0</source_block_id><sink_block_id>dtv_dvb_bbscrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bbscrambler_bb_0</source_block_id><sink_block_id>dtv_dvb_bch_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bch_bb_0</source_block_id><sink_block_id>dtv_dvb_ldpc_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_ldpc_bb_0</source_block_id><sink_block_id>dtv_dvbt2_interleaver_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_cellinterleaver_cc_0</source_block_id><sink_block_id>dtv_dvbt2_framemapper_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_framemapper_cc_0</source_block_id><sink_block_id>dtv_dvbt2_freqinterleaver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_freqinterleaver_cc_0</source_block_id><sink_block_id>dtv_dvbt2_miso_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_interleaver_bb_0</source_block_id><sink_block_id>dtv_dvbt2_modulator_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_miso_cc_0</source_block_id><sink_block_id>dtv_dvbt2_pilotgenerator_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_miso_cc_0</source_block_id><sink_block_id>dtv_dvbt2_pilotgenerator_cc_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_modulator_bc_0</source_block_id><sink_block_id>dtv_dvbt2_cellinterleaver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_p1insertion_cc_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_p1insertion_cc_0</source_block_id><sink_block_id>blocks_multiply_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_p1insertion_cc_0_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_p1insertion_cc_0_0</source_block_id><sink_block_id>blocks_multiply_const_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_pilotgenerator_cc_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_pilotgenerator_cc_1</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
